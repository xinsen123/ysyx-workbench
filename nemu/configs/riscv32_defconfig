## nemu/configs/riscv32_defconfig
```kconfig
CONFIG_CC_DEBUG=y
# CONFIG_MTRACE is not set
# CONFIG_FTRACE is not set
CONFIG_DEVICE=y
```
